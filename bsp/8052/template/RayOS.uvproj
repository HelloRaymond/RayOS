# Keil uVision project RayOS.uvproj, settings and files
target RayOS (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: RayOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\include;.\board;.\application
  group Kernel
    ../../../cpu/mcs51/c51/: context.asm
    ../../../src/: thread.c scheduler.c semaphore.c mailbox.c
  group Drivers
    ./board/: board.c
  group Application
    ./application/: main.c
