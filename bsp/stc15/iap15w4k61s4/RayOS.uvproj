# Keil uVision project RayOS.uvproj, settings and files
target RayOS (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RayOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\libraries;.\board;..\..\..\include;.\application;.\example
  group Kernel
    ../../../cpu/8051/: context.c
    ../../../src/: scheduler.c thread.c semaphore.c mailbox.c
  group Libraries
    ../libraries/: GPIO.c timer.c USART.C
  group Drivers
    ./board/: board.c
  group Application
    ./application/: main.c debug.c
    ./example/: example.c
