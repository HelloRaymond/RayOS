# Keil uVision project RayOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RayOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\os;.\user
  group Operation System
    ./os/: RayOSKernel.asm RayOS_Scheduler.c RayOS_Semaphore.c RayOS_MailBox.c
  group Application
    ./user/: main.c isr.c TM1637.c
  group Include
    ./os/: RayOS.h RayOSConfig.h
    ./user/: TM1637.h
